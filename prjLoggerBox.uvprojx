# Keil uVision project prjLoggerBox.uvprojx, settings and files
target STM32F4-Discovery (5060183::V5.06 update 2 (build 183)::ARMCC)
  device: STM32F407VGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.11.0
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: project +hex
  c flags: v6Lang=1 v6LangP=1
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER,STM32F4XX,__ASSEMBLY__,KEIL_IDE,TM_DISCO_STM32F4_DISCOVERY
  c include: ..\Mockup_1290;.\User;.\00-STM32F4xx_STANDARD_PERIPHERAL_DRIVERS\CMSIS\Device\ST\STM32F4xx\Include;.\00-STM32F4xx_STANDARD_PERIPHERAL_DRIVERS\CMSIS\Include;.\00-STM32F4xx_STANDARD_PERIPHERAL_DRIVERS\CMSIS\Device\ST\STM32F4xx\Source\Templates\arm;.\00-STM32F4xx_STANDARD_PERIPHERAL_DRIVERS\STM32F4xx_StdPeriph_Driver\inc;.\00-STM32F4xx_STANDARD_PERIPHERAL_DRIVERS\STM32F4xx_StdPeriph_Driver\src;.\00-STM32F429_LIBRARIES\fatfs;.\00-STM32F429_LIBRARIES;.\00-STM32F429_LIBRARIES\fatfs\drivers;.\00-STM32F429_LIBRARIES\fatfs\option;.\User\FreeRTOS;.\User\FreeRTOS\include;.\User\minIni-master\dev;.\User\Config;.\User\Measure;.\User\ADC_DAC;.\User\Utilites;.\User\HwAPI;.\User\UserTaskHw;.\User\UserTaskPlugins
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group CMSIS
    ./00-STM32F4xx_STANDARD_PERIPHERAL_DRIVERS/CMSIS/Device/ST/STM32F4xx/Include/: stm32f4xx.h system_stm32f4xx.h
    ./00-STM32F4xx_STANDARD_PERIPHERAL_DRIVERS/CMSIS/Device/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
  group Startup
    ./00-STM32F4xx_STANDARD_PERIPHERAL_DRIVERS/CMSIS/Device/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f40_41xxx.s
  group STD_Periph_Drivers
    ./00-STM32F4xx_STANDARD_PERIPHERAL_DRIVERS/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_rcc.c stm32f4xx_gpio.c stm32f4xx_sdio.c stm32f4xx_spi.c stm32f4xx_dma.c stm32f4xx_usart.c stm32f4xx_rtc.c stm32f4xx_exti.c stm32f4xx_pwr.c stm32f4xx_tim.c stm32f4xx_syscfg.c
  group TM
    ./00-STM32F429_LIBRARIES/: tm_stm32f4_spi.c tm_stm32f4_spi.h tm_stm32f4_fatfs.c tm_stm32f4_fatfs.h tm_stm32f4_gpio.c tm_stm32f4_gpio.h tm_stm32f4_usart.c tm_stm32f4_usart.h tm_stm32f4_rtc.c tm_stm32f4_rtc.h tm_stm32f4_delay.c tm_stm32f4_delay.h tm_stm32f4_timer_properties.c tm_stm32f4_timer_properties.h tm_stm32f4_disco.c tm_stm32f4_disco.h tm_stm32f4_exti.c tm_stm32f4_exti.h
  group FatFs
    ./00-STM32F429_LIBRARIES/fatfs/: diskio.c diskio.h ff.c ff.h ffconf.h integer.h
    ./00-STM32F429_LIBRARIES/fatfs/drivers/: fatfs_sd.c fatfs_sd.h fatfs_sd_sdio.c fatfs_sd_sdio.h
    ./00-STM32F429_LIBRARIES/fatfs/option/: syscall.c unicode.c
  group minIni
    ./User/minIni-master/dev/: minGlue-FatFs.h minIni.h minIni.c
  group FreeRTOS
    ./User/FreeRTOS/: croutine.c event_groups.c heap_1.c list.c port.c queue.c stream_buffer.c tasks.c timers.c
    ./User/: FreeRTOSConfig.h
  group HwAPI
    ./User/HwAPI/: HwAPI.h HwAPI Def.h HwAPI Config.h HwAPI_SystemTime.c HwAPI_Terminal.c HwAPI_FatFs.c HwAPI_SDCardDetect.c HwAPI_VoltageSource.c HwAPI_Relay.c HwAPI_DAQ_ADC.c HwAPI_DAQ_Frequency.c
  group UserCommon
    ./User/: main.c defines.h stm32f4xx_conf.h TS_task.h TS_queue.h
  group UserTaskHw
    ./User/UserTaskHw/: TS_HwQueue.h TS_HwSystemTime.c TS_HwTerminal.c TS_HwFatFs.c TS_HwSDCardDetect.c TS_HwVoltageSource.c TS_HwRelay.c TS_HwDAQ_ADC.c TS_HwDAQ_Frequency.c TS_HwStatusLED.c
  group UserTaskPlugins
    ./User/UserTaskPlugins/: TS_MeasurePlanner.c
  group MeasureFile
    ./User/Measure/: Measure.h Frequency_PWM.c Frequency_PWM.h
  group Utilites
    ./User/Utilites/: ClockOutMCO.c EXT_Signal.c delay.c AD56x0.c AD747x.c
